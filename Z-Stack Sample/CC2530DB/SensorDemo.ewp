# IAR project SensorDemo.ewp, settings and files
configuration CollectorEB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: HOLD_AUTO_START; BUILD_ALL_DEVICES; REFLECTOR; NV_INIT; NV_RESTORE; ZTOOL_P1; DEVICE_LOGICAL_TYPE=ZG_DEVICETYPE_ROUTER; ZIGBEEPRO; SYS_DEBUG_SH; SYS_DEBUG_RELAY
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; $_Z_HOME_$\Projects\zstack\ZMain\TI2530DB; $_Z_HOME_$\Components\hal\include; $_Z_HOME_$\Components\hal\target\CC2530EB; $_Z_HOME_$\Components\mac\include; $_Z_HOME_$\Components\mac\high_level; $_Z_HOME_$\Components\mac\low_level\srf04; $_Z_HOME_$\Components\mac\low_level\srf04\single_chip; $_Z_HOME_$\Components\mt; $_Z_HOME_$\Components\osal\include; $_Z_HOME_$\Components\services\saddr; $_Z_HOME_$\Components\services\sdata; $_Z_HOME_$\Components\stack\af; $_Z_HOME_$\Components\stack\nwk; $_Z_HOME_$\Components\stack\sapi; $_Z_HOME_$\Components\stack\sec; $_Z_HOME_$\Components\stack\sys; $_Z_HOME_$\Components\stack\zdo; $_Z_HOME_$\Components\zmac; $_Z_HOME_$\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $_Z_HOME_$\Projects\zstack\Tools\CC2530DB\f8w2530.xcl
configuration SensorEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; REFLECTOR; NV_INIT; NV_RESTORE; DEVICE_LOGICAL_TYPE=ZG_DEVICETYPE_ENDDEVICE; ZIGBEEPRO; SYS_DEBUG_SH; SYS_DEBUG_RELAY
  group App
    ../Source/: DemoApp.h DemoAppCommon.c DemoCollector.c DemoSensor.c sapi.c sapi.h
  group HAL/Common
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/hal/target/CC2530EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group MAC/High Level
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/stack/af/: AF.c AF.h
  group Security
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/services/saddr/: saddr.c saddr.h
  group Tools
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Projects/zstack/Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Components/zmac/: ZMAC.h
  group ZMain
    C:/Texas Instruments/ZStack-CC2530-2.5.1a/Projects/zstack/ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
